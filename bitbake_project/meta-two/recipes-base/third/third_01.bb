DESCRIPTION = "I AM THIRD RECIPE"
PR="r1"
inherit confbuild
